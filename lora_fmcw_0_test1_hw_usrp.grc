options:
  parameters:
    generate_options: no_gui
    id: lora_fmcw_0_test1_hw_usrp
    output_language: python
    run_command: /home/lmz/miniconda3/envs/gr310_fmcw_0/bin/python -u {filename}
    title: LoRa FMCW USRP hardware test
  states: {}

blocks:
- name: Att_dB
  id: variable
  parameters:
    comment: TX digital attenuation before UHD sink [dB]
    value: '0'
  states: {}
- name: SNRdB
  id: variable
  parameters:
    value: '-7'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: capture_out_dir
  id: variable
  parameters:
    value: '"/tmp"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 5800e6
  states: {}
- name: channel_startup_guard
  id: variable
  parameters:
    value: (preamb_len + fmcw_triangle_count) * int((2**sf) * samp_rate / bw)
  states: {}
- name: clk_offset
  id: variable
  parameters:
    comment: Clock offset in ppm
    value: '0.02'
  states: {}
- name: corr_threshold
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**5
  states: {}
- name: fmcw_cw_len
  id: variable
  parameters:
    value: '102'
  states: {}
- name: fmcw_down_len
  id: variable
  parameters:
    value: '205'
  states: {}
- name: fmcw_freq_cw
  id: variable
  parameters:
    value: '-0.45 * bw'
  states: {}
- name: fmcw_freq_sweep
  id: variable
  parameters:
    value: 0.90 * bw
  states: {}
- name: fmcw_triangle_count
  id: variable
  parameters:
    comment: FMCW triangles in the mixed preamble
    value: 'preamb_len '
  states: {}
- name: fmcw_up_len
  id: variable
  parameters:
    value: '205'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: max_out_buffer
  id: variable
  parameters:
    value: '262144'
  states: {}
- name: min_out_buffer
  id: variable
  parameters:
    value: '262144'
  states: {}
- name: os_factor
  id: variable
  parameters:
    value: int(samp_rate / bw)
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: radar_corr_threshold
  id: variable
  parameters:
    value: '0.15'
  states: {}
- name: radar_half_chirp_samples
  id: variable
  parameters:
    value: int((2**sf) * samp_rate / bw)
  states: {}
- name: radar_peak_protect
  id: variable
  parameters:
    value: '1'
  states: {}
- name: radar_peak_threshold
  id: variable
  parameters:
    value: '-120'
  states: {}
- name: radar_rx_capture_path
  id: variable
  parameters:
    value: capture_out_dir + "/lora_fmcw_0_test1_hw_usrp_radar_rx.dat"
  states: {}
- name: radar_rx_capture_samples
  id: variable
  parameters:
    value: fmcw_triangle_count * 2 * int((2**sf) * samp_rate / bw)
  states: {}
- name: radar_self_coupling
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: radar_target_range
  id: variable
  parameters:
    value: '80'
  states: {}
- name: radar_target_rcs
  id: variable
  parameters:
    value: 1e16
  states: {}
- name: radar_target_velocity
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: USRP RX gain [dB]
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    comment: USRP RX sample rate
    value: samp_rate
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    comment: USRP TX sample rate
    value: samp_rate
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '0x12'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: USRP TX gain [dB]
    value: '10'
  states: {}
- name: zero_bin_chirp_count
  id: variable
  parameters:
    comment: 0-bin LoRa chirps kept after FMCW triangles
    value: preamb_len - fmcw_triangle_count
  states: {}
- name: blocks_message_debug_inc
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_radar_down
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_radar_up
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_strobe
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.intern("helloworld : 0")'
    period: frame_period
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**((Att_dB)/20)
    minoutbuf: '10000000'
    type: complex
  states: {}
- name: blocks_null_sink_radar_rx_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: '"frame_len"'
    name: lora_before_mux
    type: complex
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: '"frame_len"'
    name: fmcw_before_mux
    type: complex
  states: {}
- name: blocks_tag_debug_2
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: '"radar_len"'
    name: radar_after_rx
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: frame_len
    minoutbuf: '2097152'
    ninputs: '2'
    type: complex
  states: {}
- name: lora_sdr_add_crc_0_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'False'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fmcw_0_frame_sync0_0
  id: lora_sdr_fmcw_0_frame_sync0
  parameters:
    bandwidth: bw
    center_freq: center_freq
    detect_corr_threshold: corr_threshold
    fmcw_preamble_len: fmcw_triangle_count
    impl_head: impl_head
    os_factor: os_factor
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: sync_word
  states: {}
- name: lora_sdr_fmcw_0_modulate0_0
  id: lora_sdr_fmcw_0_modulate0
  parameters:
    bw: bw
    frame_zero_padd: '4096'
    minoutbuf: min_out_buffer
    preamb_len: preamb_len
    samp_rate: samp_rate
    sf: sf
    sync_words: sync_word
    zero_preamble_chirps: zero_bin_chirp_count
  states: {}
- name: lora_sdr_fmcw_0_radar_estimator_updown0_0
  id: lora_sdr_fmcw_0_radar_estimator_updown0
  parameters:
    center_freq: center_freq
    push_power: 'False'
    samp_down: radar_half_chirp_samples
    samp_rate: samp_rate
    samp_up: radar_half_chirp_samples
    sweep_freq: bw
  states: {}
- name: lora_sdr_fmcw_0_radar_rx0_0
  id: lora_sdr_fmcw_0_radar_rx0
  parameters:
    bandwidth: bw
    corr_threshold: radar_corr_threshold
    len_tag_key: '"radar_len"'
    os_factor: os_factor
    sf: sf
    show_log_port: 'False'
  states: {}
- name: lora_sdr_gray_demap_0_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_payload_id_inc_0
  id: lora_sdr_payload_id_inc
  parameters:
    separator: ':'
  states: {}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'True'
  states: {}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"radar_len"'
    max_freq: '[1,1]'
    samp_protect: radar_peak_protect
    samp_rate: samp_rate
    threshold: radar_peak_threshold
  states: {}
- name: radar_find_max_peak_c_0_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"radar_len"'
    max_freq: '[1,1]'
    samp_protect: radar_peak_protect
    samp_rate: samp_rate
    threshold: radar_peak_threshold
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: fmcw_freq_cw
    freq_sweep: fmcw_freq_sweep
    len_key: '"frame_len"'
    lora_bw: bw
    lora_sf: sf
    minoutbuf: '16384'
    repeat_count: fmcw_triangle_count
    samp_cw: fmcw_cw_len
    samp_down: fmcw_down_len
    samp_rate: samp_rate
    samp_up: fmcw_up_len
  states: {}
- name: radar_signal_generator_fmcw_c_1
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: fmcw_freq_cw
    freq_sweep: fmcw_freq_sweep
    len_key: '"radar_len"'
    lora_bw: bw
    lora_sf: sf
    repeat_count: '1'
    samp_cw: fmcw_cw_len
    samp_down: fmcw_down_len
    samp_rate: samp_rate
    samp_up: fmcw_up_len
  states: {}
- name: radar_split_cc_0
  id: radar_split_cc
  parameters:
    len_key: '"radar_len"'
    packet_num: '0'
    packet_parts: '[radar_half_chirp_samples,radar_half_chirp_samples]'
  states: {}
- name: radar_split_cc_0_0
  id: radar_split_cc
  parameters:
    len_key: '"radar_len"'
    packet_num: '1'
    packet_parts: '[radar_half_chirp_samples,radar_half_chirp_samples]'
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: '"radar_len"'
    packet_len: radar_half_chirp_samples
  states: {}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: '"radar_len"'
    packet_len: radar_half_chirp_samples
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '"addr=192.168.10.2"'
    gain0: tx_gain
    len_tag_name: frame_len
    samp_rate: samp_rate_tx
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bw
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '"addr=192.168.10.2"'
    gain0: rx_gain
    minoutbuf: min_out_buffer
    samp_rate: samp_rate_rx
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0_0_0, strobe, blocks_message_debug_strobe, print]
- [blocks_message_strobe_0_0_0, strobe, lora_sdr_payload_id_inc_0, msg_in]
- [blocks_message_strobe_0_0_0, strobe, lora_sdr_whitening_0_0, msg]
- [blocks_multiply_conjugate_cc_0, '0', radar_split_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', radar_split_cc_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_multiply_const_vxx_0, '0']
- [lora_sdr_add_crc_0_0, '0', lora_sdr_hamming_enc_0_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_fmcw_0_frame_sync0_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_fmcw_0_modulate0_0, '0', blocks_tag_debug_0, '0']
- [lora_sdr_fmcw_0_modulate0_0, '0', blocks_tagged_stream_mux_0, '1']
- [lora_sdr_fmcw_0_radar_estimator_updown0_0, Msg out, radar_print_results_0, Msg in]
- [lora_sdr_fmcw_0_radar_rx0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [lora_sdr_fmcw_0_radar_rx0_0, '0', blocks_null_sink_radar_rx_0, '0']
- [lora_sdr_fmcw_0_radar_rx0_0, '0', blocks_tag_debug_2, '0']
- [lora_sdr_gray_demap_0_0, '0', lora_sdr_fmcw_0_modulate0_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0_0, '0', lora_sdr_interleaver_0_0, '0']
- [lora_sdr_header_0_0, '0', lora_sdr_add_crc_0_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_fmcw_0_frame_sync0_0, frame_info]
- [lora_sdr_interleaver_0_0, '0', lora_sdr_gray_demap_0_0, '0']
- [lora_sdr_payload_id_inc_0, msg_out, blocks_message_debug_inc, print]
- [lora_sdr_payload_id_inc_0, msg_out, blocks_message_strobe_0_0_0, set_msg]
- [lora_sdr_whitening_0_0, '0', lora_sdr_header_0_0, '0']
- [radar_find_max_peak_c_0, Msg out, blocks_message_debug_radar_up, print]
- [radar_find_max_peak_c_0, Msg out, lora_sdr_fmcw_0_radar_estimator_updown0_0, Msg in UP]
- [radar_find_max_peak_c_0_0, Msg out, blocks_message_debug_radar_down, print]
- [radar_find_max_peak_c_0_0, Msg out, lora_sdr_fmcw_0_radar_estimator_updown0_0, Msg in DOWN]
- [radar_signal_generator_fmcw_c_0, '0', blocks_tag_debug_1, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_tagged_stream_mux_0, '0']
- [radar_signal_generator_fmcw_c_1, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_split_cc_0, '0', radar_ts_fft_cc_0, '0']
- [radar_split_cc_0_0, '0', radar_ts_fft_cc_0_0, '0']
- [radar_ts_fft_cc_0, '0', radar_find_max_peak_c_0, '0']
- [radar_ts_fft_cc_0_0, '0', radar_find_max_peak_c_0_0, '0']
- [uhd_usrp_source_0_0, '0', lora_sdr_fmcw_0_frame_sync0_0, '0']
- [uhd_usrp_source_0_0, '0', lora_sdr_fmcw_0_radar_rx0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
