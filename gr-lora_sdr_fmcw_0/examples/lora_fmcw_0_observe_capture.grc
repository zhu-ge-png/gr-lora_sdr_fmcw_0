options:
  parameters:
    description: Based on lora_fmcw_0_test1, capture true MUX samples and auto-plot on exit.
    generate_options: no_gui
    id: lora_fmcw_0_observe_capture
    output_language: python
    run_command: '{python} -u /home/lmz/gr-lora_sdr_fmcw_0/examples/run_lora_fmcw_0_observe_capture.py {python} {filename} /tmp/lora_fmcw_0_observe_capture_radar.dat /tmp/lora_fmcw_0_observe_capture_mux.dat /tmp/lora_fmcw_0_observe_capture_radar_mux_timefreq.png'
    title: LoRa FMCW Observe Capture
  states: {}

blocks:
- name: SNRdB
  id: variable
  parameters:
    value: '-7'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 5800e6
  states: {}
- name: channel_startup_guard
  id: variable
  parameters:
    value: preamb_len * 2 * int((2**sf) * samp_rate / bw)
  states: {}
- name: clk_offset
  id: variable
  parameters:
    comment: Clock offset in ppm
    value: '0'
  states: {}
- name: corr_threshold
  id: variable
  parameters:
    value: '0.29'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**5
  states: {}
- name: fmcw_cw_len
  id: variable
  parameters:
    value: '102'
  states: {}
- name: fmcw_down_len
  id: variable
  parameters:
    value: '205'
  states: {}
- name: fmcw_freq_cw
  id: variable
  parameters:
    value: '-0.45 * bw'
  states: {}
- name: fmcw_freq_sweep
  id: variable
  parameters:
    value: 0.90 * bw
  states: {}
- name: fmcw_up_len
  id: variable
  parameters:
    value: '205'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: max_out_buffer
  id: variable
  parameters:
    value: '65536'
  states: {}
- name: min_out_buffer
  id: variable
  parameters:
    value: '65536'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw*4
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '0x12'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: channel_startup_guard
    type: complex
  states: {}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.intern("ASDFGHJKLZXCVB : 0")'
    period: frame_period
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: frame_len
    minoutbuf: '2097152'
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: 1.0+clk_offset*1e-6
    freq_offset: center_freq*clk_offset*1e-6/samp_rate
    minoutbuf: int((2**sf+2)*samp_rate/bw)
    noise_voltage: 10**(-SNRdB/20)
    seed: '0'
    taps: 1.0 + 0.0j
  states: {}
- name: lora_sdr_add_crc_0_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'False'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fmcw_0_frame_sync0_0
  id: lora_sdr_fmcw_0_frame_sync0
  parameters:
    bandwidth: bw
    center_freq: center_freq
    detect_corr_threshold: corr_threshold
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: sync_word
  states: {}
- name: lora_sdr_fmcw_0_modulate0_0
  id: lora_sdr_fmcw_0_modulate0
  parameters:
    bw: bw
    frame_zero_padd: '4096'
    minoutbuf: min_out_buffer
    preamb_len: preamb_len
    samp_rate: samp_rate
    sf: sf
    sync_words: sync_word
  states: {}
- name: lora_sdr_gray_demap_0_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_payload_id_inc_0
  id: lora_sdr_payload_id_inc
  parameters:
    separator: ':'
  states: {}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'True'
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: fmcw_freq_cw
    freq_sweep: fmcw_freq_sweep
    len_key: '"frame_len"'
    lora_bw: bw
    lora_sf: sf
    minoutbuf: min_out_buffer
    repeat_count: preamb_len
    samp_cw: fmcw_cw_len
    samp_down: fmcw_down_len
    samp_rate: samp_rate
    samp_up: fmcw_up_len
  states: {}
- name: capture_out_dir
  id: variable
  parameters:
    value: '"/tmp"'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int((2**sf) * samp_rate / bw)
  states: {}
- name: radar_capture_samples
  id: variable
  parameters:
    value: preamb_len * 2 * sps
  states: {}
- name: mux_capture_samples
  id: variable
  parameters:
    value: radar_capture_samples + 40000
  states: {}
- name: radar_capture_path
  id: variable
  parameters:
    value: capture_out_dir + "/lora_fmcw_0_observe_capture_radar.dat"
  states: {}
- name: mux_capture_path
  id: variable
  parameters:
    value: capture_out_dir + "/lora_fmcw_0_observe_capture_mux.dat"
  states: {}
- name: mux_figure_path
  id: variable
  parameters:
    value: capture_out_dir + "/lora_fmcw_0_observe_capture_radar_mux_timefreq.png"
  states: {}
- name: blocks_head_radar_capture_0
  id: blocks_head
  parameters:
    num_items: radar_capture_samples
    type: complex
  states: {}
- name: blocks_head_mux_capture_0
  id: blocks_head
  parameters:
    num_items: mux_capture_samples
    type: complex
  states: {}
- name: blocks_file_sink_radar_capture_0
  id: blocks_file_sink
  parameters:
    file: radar_capture_path
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_mux_capture_0
  id: blocks_file_sink
  parameters:
    file: mux_capture_path
    type: complex
    unbuffered: 'True'
  states: {}

connections:
- [blocks_delay_0, '0', channels_channel_model_0, '0']
- [blocks_message_strobe_0_0_0, strobe, lora_sdr_payload_id_inc_0, msg_in]
- [blocks_message_strobe_0_0_0, strobe, lora_sdr_whitening_0_0, msg]
- [blocks_tagged_stream_mux_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [channels_channel_model_0, '0', lora_sdr_fmcw_0_frame_sync0_0, '0']
- [lora_sdr_add_crc_0_0, '0', lora_sdr_hamming_enc_0_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_fmcw_0_frame_sync0_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_fmcw_0_modulate0_0, '0', blocks_tagged_stream_mux_0, '1']
- [lora_sdr_gray_demap_0_0, '0', lora_sdr_fmcw_0_modulate0_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0_0, '0', lora_sdr_interleaver_0_0, '0']
- [lora_sdr_header_0_0, '0', lora_sdr_add_crc_0_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_fmcw_0_frame_sync0_0, frame_info]
- [lora_sdr_interleaver_0_0, '0', lora_sdr_gray_demap_0_0, '0']
- [lora_sdr_payload_id_inc_0, msg_out, blocks_message_strobe_0_0_0, set_msg]
- [lora_sdr_whitening_0_0, '0', lora_sdr_header_0_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_tagged_stream_mux_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_head_radar_capture_0, '0']
- [blocks_head_radar_capture_0, '0', blocks_file_sink_radar_capture_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_head_mux_capture_0, '0']
- [blocks_head_mux_capture_0, '0', blocks_file_sink_mux_capture_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
