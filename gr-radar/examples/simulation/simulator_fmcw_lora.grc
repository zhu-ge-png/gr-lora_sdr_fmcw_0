options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulator_fmcw
    output_language: python
  states: {}

blocks:
- name: SNRdB
  id: variable
  parameters:
    value: '-5'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '78125'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 5.9e9
  states: {}
- name: clk_offset
  id: variable
  parameters:
    comment: Clock offset in ppm
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim_fac
  id: variable
  parameters:
    value: 2**5
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: max_out_buffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: meas_duration
  id: variable
  parameters:
    value: (samp_cw+samp_up+samp_down)/float(samp_rate)
  states: {}
- name: min_out_buffer
  id: variable
  parameters:
    value: int((samp_up+samp_down+samp_cw)*2)
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: protect_samp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: range_res
  id: variable
  parameters:
    value: 3e8/2/sweep_freq
  states: {}
- name: samp_cw
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: samp_down
  id: variable
  parameters:
    value: samp_up
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samp_up
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: sweep_freq
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '0x12'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '-120'
    step: '1'
    stop: '0'
    value: '-120'
  states: {}
- name: v_res
  id: variable
  parameters:
    value: samp_rate/samp_cw*3e8/2/center_freq
  states: {}
- name: value_range
  id: variable_qtgui_range
  parameters:
    label: range
    start: '0'
    step: '1'
    stop: '1000'
    value: '200'
  states: {}
- name: velocity
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    minoutbuf: min_out_buffer
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi)
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    minoutbuf: min_out_buffer
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/lmz/gr-radar/examples/simulation/fmcw_lora_wave.dat
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '300000'
    type: float
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("A")
    period: '2000'
  states: {state: disabled}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("helloworld")
    period: '200'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    minoutbuf: min_out_buffer
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"frame_len"'
    name: LORA_tags
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"frame_len"'
    name: FMCW_tags
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/decim_fac
    lengthtagname: '"packet_len"'
    minoutbuf: min_out_buffer
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: frame_len
    minoutbuf: '2097152'
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    minoutbuf: min_out_buffer
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {state: disabled}
- name: lora_sdr_add_crc_0_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_gray_demap_0_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {state: disabled}
- name: lora_sdr_hamming_enc_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {state: disabled}
- name: lora_sdr_header_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '0'
    sf: sf
  states: {state: disabled}
- name: lora_sdr_interleaver_0_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: '0'
    minoutbuf: '10000000'
    preamb_len: preamb_len
    samp_rate: int(bw*4)
    sf: sf
    sync_words: sync_word
  states: {state: disabled}
- name: lora_sdr_modulate_0_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: '0'
    minoutbuf: '10000000'
    preamb_len: preamb_len
    samp_rate: samp_rate
    sf: sf
    sync_words: sync_word
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'True'
  states: {state: disabled}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_cw//decim_fac
    name: CW
    plotfreq: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_up//decim_fac
    name: UP
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim_fac
    fc: '0'
    fftsize: samp_up//decim_fac
    name: DOWN
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '49152'
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: 3.5e6
    ymin: '-3.5e6'
    yunit: '"MHZ"'
  states: {state: disabled}
- name: radar_estimator_fmcw_0
  id: radar_estimator_fmcw
  parameters:
    center_freq: center_freq
    push_power: 'False'
    samp_down: samp_down//decim_fac
    samp_rate: samp_rate//decim_fac
    samp_up: samp_up//decim_fac
    sweep_freq: sweep_freq
  states: {state: disabled}
- name: radar_find_max_peak_c_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[1,1]'
    samp_protect: protect_samp
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {state: disabled}
- name: radar_find_max_peak_c_0_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[1,1]'
    samp_protect: protect_samp
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {state: disabled}
- name: radar_find_max_peak_c_0_0_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[1,1]'
    samp_protect: protect_samp
    samp_rate: samp_rate//decim_fac
    threshold: threshold
  states: {state: disabled}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {state: disabled}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: '-sweep_freq/2'
    freq_sweep: sweep_freq
    len_key: '"frame_len"'
    minoutbuf: min_out_buffer
    samp_cw: samp_cw
    samp_down: samp_down
    samp_rate: samp_rate
    samp_up: samp_up
  states: {}
- name: radar_split_cc_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_out_buffer
    packet_num: '0'
    packet_parts: '[samp_cw//decim_fac,samp_up//decim_fac,samp_down//decim_fac]'
  states: {state: disabled}
- name: radar_split_cc_0_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_out_buffer
    packet_num: '1'
    packet_parts: '[samp_cw//decim_fac,samp_up//decim_fac,samp_down//decim_fac]'
  states: {state: disabled}
- name: radar_split_cc_0_0_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    minoutbuf: min_out_buffer
    packet_num: '2'
    packet_parts: '[samp_cw//decim_fac,samp_up//decim_fac,samp_down//decim_fac]'
  states: {state: disabled}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: center_freq
    len_key: '"packet_len"'
    minoutbuf: min_out_buffer
    position_rx: '0'
    range: value_range
    rcs: 1e16
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: velocity
  states: {state: disabled}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_cw//decim_fac
  states: {state: disabled}
- name: radar_ts_fft_cc_0_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_up//decim_fac
  states: {state: disabled}
- name: radar_ts_fft_cc_0_1
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: samp_down//decim_fac
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_fac
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_head_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_message_strobe_0_0, strobe, lora_sdr_whitening_0, msg]
- [blocks_message_strobe_0_0_0, strobe, lora_sdr_whitening_0_0, msg]
- [blocks_multiply_conjugate_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', radar_split_cc_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', radar_static_target_simulator_cc_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_add_crc_0_0, '0', lora_sdr_hamming_enc_0_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_demap_0_0, '0', lora_sdr_modulate_0_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_hamming_enc_0_0, '0', lora_sdr_interleaver_0_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_0_0, '0', lora_sdr_add_crc_0_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_interleaver_0_0, '0', lora_sdr_gray_demap_0_0, '0']
- [lora_sdr_modulate_0_0, '0', blocks_tag_debug_0, '0']
- [lora_sdr_modulate_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [lora_sdr_whitening_0_0, '0', lora_sdr_header_0_0, '0']
- [radar_estimator_fmcw_0, Msg out, radar_print_results_0, Msg in]
- [radar_find_max_peak_c_0, Msg out, radar_estimator_fmcw_0, Msg in CW]
- [radar_find_max_peak_c_0_0, Msg out, radar_estimator_fmcw_0, Msg in UP]
- [radar_find_max_peak_c_0_0_0, Msg out, radar_estimator_fmcw_0, Msg in DOWN]
- [radar_signal_generator_fmcw_c_0, '0', analog_quadrature_demod_cf_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_tag_debug_0_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_tagged_stream_mux_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_throttle_0, '0']
- [radar_split_cc_0, '0', qtgui_sink_x_0, '0']
- [radar_split_cc_0, '0', radar_ts_fft_cc_0, '0']
- [radar_split_cc_0_0, '0', qtgui_sink_x_0_0, '0']
- [radar_split_cc_0_0, '0', radar_ts_fft_cc_0_0, '0']
- [radar_split_cc_0_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [radar_split_cc_0_0_0, '0', radar_ts_fft_cc_0_1, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_add_xx_0, '1']
- [radar_ts_fft_cc_0, '0', radar_find_max_peak_c_0, '0']
- [radar_ts_fft_cc_0_0, '0', radar_find_max_peak_c_0_0, '0']
- [radar_ts_fft_cc_0_1, '0', radar_find_max_peak_c_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
